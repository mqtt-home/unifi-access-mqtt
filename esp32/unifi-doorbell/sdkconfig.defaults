## esp32/unifi-doorbell/sdkconfig.defaults
```kconfig
# Enable WebSocket client component
CONFIG_ESP_WEBSOCKET_CLIENT_ENABLE=y
CONFIG_WEBSOCKET_BUFFER_SIZE=8192
```
